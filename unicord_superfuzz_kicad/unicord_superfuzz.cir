.title KiCad schematic
.include "1n34a_for_da-90.lib"
.include "2N5088_for_2SC828.LIB"
.include "BC549_for_2SC539.lib"
Q1 Net-_Q1-Pad1_ Net-_C3-Pad2_ Net-_C2-Pad1_ BC549/550
Q2 Net-_C5-Pad1_ VCC Net-_C3-Pad2_ 2N5088
C3 VCC Net-_C3-Pad2_ 0.002
C5 Net-_C5-Pad1_ Net-_C5-Pad2_ 10u
C4 Net-_C4-Pad1_ GND 0.1u
R5 VCC Net-_C3-Pad2_ 47k
R2 Net-_C2-Pad1_ Net-_C4-Pad1_ 100k
R3 Net-_C2-Pad1_ GND 100k
R4 Net-_Q1-Pad1_ GND 1.8k
R6 Net-_C5-Pad1_ Net-_C4-Pad1_ 470k
R7 Net-_C5-Pad1_ GND 10k
R8 Net-_C5-Pad2_ Net-_C4-Pad1_ 47k
Q3 Net-_C9-Pad2_ Net-_C8-Pad2_ Net-_C7-Pad1_ 2N5088
C7 Net-_C7-Pad1_ Net-_C7-Pad2_ 10u
C6 Net-_C6-Pad1_ Net-_C5-Pad1_ 10u
R10 VCC Net-_C7-Pad1_ 220k
R9 Net-_R32-Pad2_ GND 3.3k
R12 VCC Net-_C8-Pad2_ 10k
C8 Net-_C8-Pad1_ Net-_C8-Pad2_ 10u
R14 Net-_Q4-Pad3_ Net-_C8-Pad1_ 470k
R13 Net-_C9-Pad2_ GND 10k
R11 Net-_C7-Pad1_ GND 150k
R21 VCC Net-_C11-Pad2_ 10k
R16 VCC Net-_Q4-Pad3_ 100k
C11 Net-_C11-Pad1_ Net-_C11-Pad2_ 10u
C12 Net-_C12-Pad1_ Net-_C11-Pad1_ 10u
Q5 Net-_C10-Pad1_ Net-_C11-Pad2_ Net-_Q5-Pad3_ BC549/550
C10 Net-_C10-Pad1_ GND 10u
R18 Net-_C10-Pad1_ GND 1.8k
R15 Net-_Q5-Pad3_ Net-_C9-Pad1_ 470k
C9 Net-_C9-Pad1_ Net-_C9-Pad2_ 10u
R22 Net-_C12-Pad1_ Net-_R22-Pad2_ 47k
R23 Net-_R22-Pad2_ GND 10k
Q6 Net-_Q6-Pad1_ Net-_C16-Pad2_ Net-_C15-Pad1_ BC549/550
C15 Net-_C15-Pad1_ Net-_C15-Pad2_ 10u
R26 VCC Net-_C15-Pad1_ 100k
R27 Net-_C15-Pad1_ GND 15k
R29 Net-_Q6-Pad1_ GND 1k
R28 VCC Net-_C16-Pad2_ 10k
C16 Output Net-_C16-Pad2_ 10u
R30 Output GND 100k
C1 VCC GND 10u
D1 GND Net-_C11-Pad1_ 1N34A
D2 Net-_C11-Pad1_ GND 1N34A
R17 Net-_Q4-Pad3_ Net-_R17-Pad2_ 22k
Q4 Net-_C10-Pad1_ Net-_C11-Pad2_ Net-_Q4-Pad3_ BC549/550
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 10u
R1 Net-_C2-Pad2_ Input 22k
R19 VCC Net-_Q5-Pad3_ 100k
R20 Net-_Q5-Pad3_ Net-_R20-Pad2_ 22k
R32 Net-_C7-Pad2_ Net-_R32-Pad2_ 22k
R31 Net-_C6-Pad1_ Net-_C7-Pad2_ 22k
R25 Net-_C15-Pad2_ GND 22k
R24 Net-_R22-Pad2_ Net-_C15-Pad2_ 22k
R33 Net-_R17-Pad2_ GND 3.3k
R34 GND Net-_R20-Pad2_ 3.3k
VJ1 Input ac 10
IJ3 VCC dc 12
IJ2 GND dc 0
.end
